.ic V(Q1)=1.2 V(Q0)=0
